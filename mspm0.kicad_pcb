# Repository Alipay1/MSPM0G3507_core_board

File README.md:

# MSPM0G3507_core_board
 
>_注意：这是KiCAD工程！_

## 功能

* 板载135*240LCD屏幕
* DC电源接口
* 总电源拨动开关
* 12V、5V、3.3V电源排针接口
* TYPE-C供电接口
* 提供CAN-FD接口（未验证）
* 提供三个用户按键
* 提供两个板载LED
* 提供重启键、BSL键
* 引出串口（GH1.25 4P）、SWD接口（MX1.25 4P）

## 特点

* 支持3S锂电池供电
* 12V、5V电源具备TVS保护
* 板载外设可通过电阻使能
* 一键进入BSL
* CAN接口TVS保护
* TYPE-C接口500mA保险丝保护
* 芯片排针接口间距为100mil整倍数，方便洞洞板插接

## 视频演示
`https://www.bilibili.com/video/BV1tr42137Vm/`
## 示例代码
`https://github.com/Alipay1/mspm0g3507_dev_board_example`

## KiCad design mspm0.kicad_pcb

File readme.txt:

工具版本信息：
Application: KiCad x64 on x64

Version: 8.0.1, release build

Libraries:
	wxWidgets 3.2.4
	FreeType 2.12.1
	HarfBuzz 8.3.0
	FontConfig 2.14.2
	libcurl/8.5.0-DEV Schannel zlib/1.3

Platform: Windows 11 (构建 22631)，64位版, 64 bit, Little endian, wxMSW

Build Info:
	Date: Mar 15 2024 01:52:47
	wxWidgets: 3.2.4 (wchar_t,wx containers)
	Boost: 1.83.0
	OCC: 7.7.1
	Curl: 8.5.0-DEV
	ngspice: 42
	Compiler: Visual C++ 1936 without C++ ABI

文件结构：
readme.txt———————本文件
ibom.html————————交互式BOM表
mspm0.kicad_pcb——PCB文件
mspm0.kicad_prl——工程配置文件
mspm0.kicad_pro——KiCad工程文件
mspm0.kicad_sch——原理图文件
out/—————————————制造输出文件夹（请重新生成）

Parts:
C1, C2, C16, C17: 47uF 25V; CP_Elec_6.3x5.4
C3: 75pF; R_0603_1608Metric
C4, C22, C25, C26, C27, C29, C30, C31: 100nF; C_0603_1608Metric
C5: 100nF; C_0805_2012Metric
C6, C7, C8: 22uF; C_0805_2012Metric
C9, C15: 56pF; C_0603_1608Metric
C10, C11: 22uF; C_0603_1608Metric
C12: 22pF; C_0603_1608Metric
C13, C14, C18, C19, C20, C21: 1uF; C_0603_1608Metric
C23: 10uF; C_0603_1608Metric
C24, C28: 12pF; C_0603_1608Metric
D1: SS34; D_SMA
D2: SMAJ12A; D_SMA
D3: NUP2105L; SOT-23
D4, D5, D6, D7, D9, D10, D11, D12: LED; LED_0603_1608Metric
D8, D14: SMF5V0A; D_SMF
D13: 1N4148W; D_SOD-323
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: Barrel_Jack_Switch_Pin3Ring; BarrelJack_Horizontal
J2: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J3, J4, J6, J7: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_01x04_MountingPin; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J8: Conn_01x02_MountingPin; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J9, J12: Conn_01x18_Pin; PinHeader_1x18_P2.54mm_Vertical
J10: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal
J11: Conn_01x04_MountingPin; Molex_PicoBlade_53261-0471_1x04-1MP_P1.25mm_Horizontal
L1: 10uH; L_7.3x6.6mm
L2: 2.2uH; L_Changjiang_FNR252012S
Q1, Q2, Q3: S8050; SOT-23
R1, R40, R42, R44: 100k; R_0603_1608Metric
R2: 13.3k; R_0603_1608Metric
R3: 49.9; R_0603_1608Metric
R4, R13, R25, R26: 33; R_0603_1608Metric
R5, R12, R38, R45, R46: 100; R_0603_1608Metric
R6: 68k; R_0603_1608Metric
R7, R8, R23, R36: 1k; R_0603_1608Metric
R9, R11: 62; R_0603_1608Metric
R10: 15k; R_0603_1608Metric
R14, R16, R17, R24, R29, R33, R34, R35, R37, R47, R48: 10k; R_0603_1608Metric
R15: 0R; R_0805_2012Metric
R18, R19, R20, R21, R22, R30, R31, R39, R41, R43: 0R; R_0603_1608Metric
R27, R28: 5.1k; R_0402_1005Metric
R32: 100k ±0.1% 25ppm; R_0603_1608Metric
S1: 焊接式_TFT_1.14_135X240_13PIN; JLC_3DModel_Q 2f6c02c867a549178f5564592e40b008
SW1, SW2, SW3, SW4, SW5: SW_Push; SW_SPST_CK_RS282G05A3
U1: HX_SS12D10G4; SW-TH_SHOU-HAN_SS12D10G4
U2: TPS54302; SOT-23-6
U3: SY8089; SOT-23-5
U4: TJA1044GTK/3Z; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm
U5: RT9013-33GB; SOT-23-5
U6: XMSM0G3507SPT; PT0048A-IPC_A
Y1: 8MHz ±10ppm 12pF; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C21.1, C22.1, C23.1, D7.2 (A), D10.2 (A), D11.2 (A), J11.4, R30.1, R35.1, R36.1, R40.2, R42.2, R44.2, SW5.2, U5.5 (VOUT), U6.6 (VDD)
+3.3VP: C11.1, C12.1, C14.1, C17.1, D6.2 (A), J6.1, J6.2, J6.3, J6.4, L2.1, R6.1, S1.10 (VCC), S1.12 (VCC), U4.5 (VIO)
+5V: C6.1, C7.1, C10.1, C13.2, C16.1, D5.2 (A), D14.1 (A1), J4.1, J4.2, J4.3, J4.4, J5.4, L1.2, R3.1, R15.2, U3.1 (EN), U3.4 (IN), U4.3 (VCC)
+12V: C1.1, C2.1, D1.2 (A), D2.1 (K), D4.2 (A), J3.1, J3.2, J3.3, J3.4, U1.2, U1.3
/BSL_invoke: D12.2 (A), Q3.2 (E), R37.1, U6.33 (PA18_A1_3)
/CANFD_RX: R13.1, U6.28 (PA13_CAN_RX)
/CANFD_TX: R4.1, U6.27 (PA12_CAN_TX)
/HFXIN: C24.2, U6.11 (PA5_HFXIN), Y1.1
/HFXOUT: C28.2, U6.12 (PA6_HFXOUT), Y1.3
/LCD_BLK: J9.16, R23.2, U6.32 (PA17_A1_2)
/LCD_CLK: R21.1, S1.4 (SCL)
/LCD_CS: R20.1, S1.7 (CS)
/LCD_DC: R19.1, S1.5 (DC)
/LCD_RES: R18.1, S1.6 (RES)
/LCD_SDA: R22.1, S1.3 (SDA)
/NRST: C25.2, Q2.3 (C), R35.2, SW3.1, U6.4 (RST_N)
/PA0: J9.5, R41.2, U6.1 (PA0)
/PA1: J9.4, R43.2, U6.2 (PA1)
/PA3: R47.2, U6.9 (PA3_LFXIN)
/PA4: R48.2, U6.10 (PA4_LFXOUT)
/PA7: J12.2, U6.13 (PA7)
/PA8: J12.5, R20.2, U6.16 (PA8)
/PA9: J12.6, R39.2, U6.17 (PA9)
/PA10: J5.1, J12.7, U6.18 (PA10)
/PA11: J5.2, J12.8, U6.19 (PA11)
/PA14: J12.16, U6.29 (PA14)
/PA15_A1_0: J12.17, U6.30 (PA15_A1_0)
/PA16_A1_1: J9.17, U6.31 (PA16_A1_1)
/PA19_SWDIO: J11.1, R26.1
/PA20_SWCLK: J11.2, R25.1
/PA22_A0_7: J9.12, U6.40 (PA22_A0_7)
/PA24_A0_3: J9.9, U6.44 (PA24_A0_3)
/PA25_A0_2: J9.8, U6.45 (PA25_A0_2)
/PA26_A0_1: J9.7, U6.46 (PA26_A0_1_CAN_TX)
/PA27_A0_0: J9.6, U6.47 (PA27_A0_0_CAN_RX)
/PA28: J9.3, U6.3 (PA28)
/PA31: J9.2, U6.5 (PA31)
/PB2: J12.3, U6.14 (PB2)
/PB3: J12.4, U6.15 (PB3)
/PB6: J12.9, U6.20 (PB6)
/PB7: J12.10, U6.21 (PB7)
/PB8: J12.11, U6.22 (PB8)
/PB9: J12.12, U6.23 (PB9)
/PB14: J12.13, U6.24 (PB14)
/PB15: J12.14, U6.25 (PB15)
/PB16: J12.15, U6.26 (PB16)
/PB17_A1_4: J9.15, R22.2, U6.36 (PB17_A1_4)
/PB18_A1_5: J9.14, R21.2, U6.37 (PB18_A1_5)
/PB19_A1_6: J9.13, U6.38 (PB19_A1_6)
/PB20_A0_6: J9.11, R19.2, U6.41 (PB20_A0_6)
/PB24_A0_5: J9.10, R18.2, U6.42 (PB24_A0_5)
/SW1: C29.2, R38.2, R39.1, R40.1
/SW2: C30.2, R41.1, R42.1, R45.2
/SW3: C31.2, R43.1, R44.1, R46.2
/VREF+: C19.1, R30.2, U6.39 (PA21_A1_7_VREF-)
GND: C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.1, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, D2.2 (A), D3.3 (A), D8.2 (A2), D9.1 (K), D12.1 (K), D14.2 (A2), J1.2, J1.3, J2.1, J5.3, J5.MP (MountPin), J7.1, J7.2, J7.3, J7.4, J8.MP (MountPin), J9.18, J10.A12 (GND), J10.B12 (GND), J10.S1 (SHIELD), J11.3, J11.MP (MountPin), J12.1, Q1.2 (E), Q2.2 (E), R2.2, R7.1, R8.1, R10.2, R14.1, R16.1, R17.1, R24.1, R27.2, R28.2, R32.1, R33.2, R37.2, S1.8 (GND), S1.13 (GND), SW1.1, SW2.1, SW3.2, SW4.1, U2.1 (GND), U3.2 (GND), U4.2 (GND), U4.9 (EP), U5.2 (GND), U6.7 (VSS), U6.43 (PA23_VREF+), Y1.2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
unnamed: C3.1, R1.1, R3.2
unnamed: C5.1, C8.1, D1.1 (K), U2.3 (VIN)
unnamed: D4.1 (K), R14.2
unnamed: D5.1 (K), R16.2
unnamed: D6.1 (K), R17.2
unnamed: D7.1 (K), R24.2
unnamed: D9.2 (A), R29.1
unnamed: D10.1 (K), R47.1
unnamed: D11.1 (K), R48.1
unnamed: D13.2 (A), R34.2, SW5.1
unnamed: C26.2, D13.1 (K), Q3.1 (B)
unnamed: J1.1, J2.2, U1.1
unnamed: C15.1, D3.1 (K), J8.1, R11.1, R12.2
unnamed: C9.1, D3.2 (K), J8.2, R5.2, R9.2
unnamed: J10.A5 (CC1), R27.1
unnamed: J10.B5 (CC2), R28.1
unnamed: Q1.1 (B), R7.2, R23.1
unnamed: Q1.3 (C), S1.11 (LEDK)
unnamed: C27.2, Q2.1 (B), R33.1, R34.1
unnamed: Q3.3 (C), R36.2
unnamed: R9.1, R11.2
unnamed: R38.1, SW1.2
unnamed: R45.1, SW2.2
unnamed: R46.1, SW4.2
unnamed: C4.1, U2.6 (BOOT)
unnamed: C3.2, R1.2, R2.1, U2.4 (FB)
unnamed: C4.2, L1.1, U2.2 (SW)
unnamed: C12.2, R6.2, R10.1, U3.5 (FB)
unnamed: L2.2, U3.3 (LX)
unnamed: R5.1, U4.7 (CANH)
unnamed: R12.1, U4.6 (CANL)
unnamed: R13.2, U4.4 (RXD)
unnamed: R8.2, U4.8 (STB)
unnamed: R4.2, U4.1 (TXD)
unnamed: C20.1, R31.1, U5.1 (VIN)
unnamed: R32.2, U6.8 (PA2_ROSC)
unnamed: R26.2, U6.34 (PA19_SWDIO)
unnamed: R25.2, U6.35 (PA20_SWCLK)
unnamed: C18.1, U6.48 (VCORE)
VBUS: D8.1 (A1), J9.1, J10.A9 (VBUS), J10.B9 (VBUS), J12.18, R15.1, R29.2, R31.2, U5.3 (EN)

Notes on the sheet:
安装孔
一键BOOT电路 按下SW1后Q1导通BOOT0为高电平 同时Q2导通NRST被拉低，MCU复位 松开SW1后由于C7持续放电，且回路串有10k电阻 导致NRST跳变至高电平时BOOT0 = 1 进入下载模式
VBUS is 5V
灯亮正常
Place close to MCU VCC -> 10uF -> 0.1uF -> MCU

Board: 4 copper layers, 66.8 x 85.8 mm, 127 parts (3 on the bottom side), 96 nets.

## Commit log

2024-07-16 fixed floating bsl_pin
2024-07-16 updated silkscreen rev version number
